# Keil uVision project Time_Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Time_Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Time.c chang_function_2.h Time_sub_Function.h
